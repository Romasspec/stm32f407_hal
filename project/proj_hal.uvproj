# Keil uVision project proj_hal.uvproj, settings and files
target proj_hal (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: proj_hal +hex
  c flags: Optim=1
  c define: STM32F407xx
  c misc: --c99
  c include: ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\STM32F4xx_HAL_Driver\Src;..\Inc;..\Src;..\startup
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../startup/: startup_stm32f40xx.s
  group Src
    ../Src/: main.c system_stm32f4xx.c stm32f4xx_hal_msp.c stm32f4xx_it.c ILI9341_STM32_Driver.cpp
  group Inc
    ../Inc/: main.h stm32f4xx_hal_conf.h stm32f4xx_it.h
  group CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h stm32f407xx.h system_stm32f4xx.h
  group Driver
    ../Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_gpio.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_spi.h stm32f4xx_hal_dma.h
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_dma.c
